###################################################################################################
# Contains the recipe to download the release binaries from Microsoft for the version
# 7.0.0 ASP .Net Core runtime.
# Original version Copyright Richard Dunkley 2020
# Modified for 7.0.0 by Jan Philipp Giel 2022
###################################################################################################

require recipes-runtime/aspnet-core/aspnet-core_7.0.0.inc
require recipes-runtime/aspnet-core/aspnet-core_7.x.x.inc
