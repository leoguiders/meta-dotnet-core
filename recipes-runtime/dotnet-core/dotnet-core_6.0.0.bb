###################################################################################################
# Contains the recipe to download the release binaries from Microsoft for the version
# 6.0.0 .Net Core runtime.
# Original version Copyright Richard Dunkley 2020
# Modified for 6.0.0 by Jan Philipp Giel 2021
###################################################################################################
require recipes-runtime/dotnet-core/dotnet-core_6.0.0.inc
require recipes-runtime/dotnet-core/dotnet-core_6.x.x.inc

