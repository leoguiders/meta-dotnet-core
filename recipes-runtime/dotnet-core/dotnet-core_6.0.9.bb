###################################################################################################
# Contains the recipe to download the release binaries from Microsoft for the version
# 6.0.9 .Net Core runtime.
# Original version Copyright Richard Dunkley 2020
# Modified for 6.0.9 by Jan Philipp Giel 2022
###################################################################################################
require recipes-runtime/dotnet-core/dotnet-core_6.0.9.inc
require recipes-runtime/dotnet-core/dotnet-core_6.x.x.inc

