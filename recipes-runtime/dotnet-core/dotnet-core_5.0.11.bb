###################################################################################################
# Contains the recipe to download the release binaries from Microsoft for the version
# 5.0.11 .Net Core runtime.
# Original version Copyright Richard Dunkley 2020
# Modified for 5.0.11 by Jan Philipp Giel 2021
###################################################################################################
require recipes-runtime/dotnet-core/dotnet-core_5.0.11.inc
require recipes-runtime/dotnet-core/dotnet-core_5.x.x.inc

